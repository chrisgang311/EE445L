# Keil uVision project ADCPrintResults.uvproj, settings and files
target ADCPrintResults (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: ADCPrintResults
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s UART.c main.c PLL.c Timer.c ADCHWTrigger.c LCD.c ST7735.c
  group Triggers
    ./: ADCContinuous.c ADCSWTrigger.c ADCT0ATrigger.c
